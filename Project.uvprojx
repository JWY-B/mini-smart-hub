# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\Hardware;.\System;.\Fonts;.\lvgl;.\lvgl\src;.\lvgl\examples\porting;.\custom;.\generated\images;.\generated\guider_fonts;.\generated\guider_customer_fonts;.\generated
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c core_cm3.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: LCD.c LCD.h Serial.c Serial.h XPT2046.h
    ./HardWare/: XPT2046.c
  group System
    ./System/: Delay.c Delay.h TIM3.c TIM3.h
  group Fonts
    ./Fonts/: ASCII_Font.h
  group LVGL_conf
    ./lvgl/: lv_conf.h lvgl.h
  group LVGL_porting
    ./lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ./lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ./lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./lvgl/src/extra/: lv_extra.c
    ./lvgl/src/extra/widgets/win/: lv_win.c
    ./lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./lvgl/src/extra/widgets/span/: lv_span.c
    ./lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./lvgl/src/extra/widgets/meter/: lv_meter.c
    ./lvgl/src/extra/widgets/menu/: lv_menu.c
    ./lvgl/src/extra/widgets/list/: lv_list.c
    ./lvgl/src/extra/widgets/led/: lv_led.c
    ./lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./lvgl/src/extra/widgets/chart/: lv_chart.c
    ./lvgl/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    ./lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./lvgl/src/extra/themes/default/: lv_theme_default.c
    ./lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ./lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ./lvgl/src/extra/others/monkey/: lv_monkey.c
    ./lvgl/src/extra/others/msg/: lv_msg.c
    ./lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./lvgl/src/extra/layouts/flex/: lv_flex.c
    ./lvgl/src/extra/layouts/grid/: lv_grid.c
    ./lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group GUI
    ./custom/: custom.c
    ./generated/: events_init.c setup_scr_screen.c widgets_init.c gui_guider.c gui_guider.h
    ./generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c
